# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: Project +hex
  AfterMake: fromelf.exe --bin --output ./Out_Files/Project.bin ./Objects/Project.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Core_Drivers\CMSIS;..\Core_Drivers\Device;..\Core_Drivers\HAL_Driver\Inc;..\user;..\APP\Inc;..\BSP\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CoreDriver/CMSIS
    ../Core_Drivers/CMSIS/: core_cm0.h
  group CoreDriver/Device
    ../Core_Drivers/Device/: ACM32F0x0.h Startup_ACM32F0x0.s System_ACM32F0x0.c System_ACM32F0x0.h
  group CoreDriver/HAL
    ../Core_Drivers/HAL_Driver/Src/: HAL_ADC.c HAL_CAN.c HAL_COMP.c HAL_CRC.c HAL_DIV.c HAL_EXTI.c HAL_I2C.c HAL_IWDT.c HAL_LCD.c HAL_LPUART.c HAL_OPA.c HAL_RTC.c HAL_SPI.c HAL_TIMER.c HAL_TKEY.c HAL_UART_EX.c HAL_WDT.c HAL_DMA.c HAL_EFLASH.c HAL_GPIO.c HAL_UART.c HAL_EFlash_EX.lib HAL_HRNG_20210422.lib
  group USER
    ../user/: main.c
  group BSP
    ../BSP/Src/: bsp.c delay.c lcd.c spi.c uart.c 24cxx.c rtc.c sys.c adc.c pwm.c timer.c audio.c comp.c bt.c key.c hlw8112.c display.c
  group PIC
    ../BSP/Src/: car.c
  group DOC
    ../DOC/: readme.txt
